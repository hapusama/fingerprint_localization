options:
  parameters:
    author: oyc
    category: '[Dong]'
    description: Low-rate Chime-style LFM upchirp transmitter using a repeated fc32 waveform file
    gen_cmake: 'Off'
    generate_options: qt_gui
    id: chime_wideband_tx
    output_language: python
    run_options: run
    title: Chime Wideband TX
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: '487700000'
  states: {}
- name: rf_bandwidth
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: tx_device_addr
  id: variable
  parameters:
    comment: Change this if the TX USRP is the other radio.
    value: '"serial=2512552"'
  states: {}
- name: tx_gain_db
  id: variable
  parameters:
    comment: Absolute B210 TX gain in dB.
    value: '100'
  states: {}
- name: tx_samples
  id: variable
  parameters:
    value: int(samp_rate * tx_seconds)
  states: {}
- name: tx_seconds
  id: variable
  parameters:
    comment: Flowgraph stops after this many seconds.
    value: '10'
  states: {}
- name: waveform_file
  id: variable
  parameters:
    comment: One 20 ms fc32 chirp period generated by chime_wideband_make_tx_waveform.py.
    value: r"D:\Desktop\fingerprint_localization\dong\inputs\chime_test_tx_period_fc32.bin"
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters:
    comment: 把送往 USRP Sink 的复数 IQ 转成幅度包络，用来确认 TX 模板确实在流动。
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    comment: Repeats one chirp period from disk/cache.
    file: waveform_file
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: tx_samples
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    comment: 实时观察 TX 幅度包络；接在 Head 后面，所以它显示的就是本次送入 USRP Sink 的样本。
    ctrlpanel: 'True'
    grid: 'True'
    label1: TX |IQ| envelope
    name: TX Time Amplitude
    size: int(samp_rate * 0.025)
    srate: samp_rate
    type: float
    ymax: '0.3'
    ymin: '0'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: rf_bandwidth
    center_freq0: center_freq
    clock_source0: internal
    dev_addr: tx_device_addr
    dev_args: '""'
    gain0: tx_gain_db
    otw: sc16
    samp_rate: samp_rate
    stream_args: '""'
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_file_source_0, '0', blocks_head_0, '0']
- [blocks_head_0, '0', blocks_complex_to_mag_0, '0']
- [blocks_head_0, '0', uhd_usrp_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
