options:
  parameters:
    author: oyc
    category: '[Dong]'
    description: Low-rate Chime-style LFM upchirp transmitter using a repeated fc32 waveform file
    gen_cmake: 'Off'
    generate_options: no_gui
    id: chime_wideband_tx
    output_language: python
    run_options: run
    title: Chime Wideband TX
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: '487700000'
  states: {}
- name: rf_bandwidth
  id: variable
  parameters:
    value: '20000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '20000000'
  states: {}
- name: tx_device_addr
  id: variable
  parameters:
    comment: Change this if the TX USRP is the other radio. Extra UHD send frames help absorb host scheduling jitter at 20 MS/s.
    value: '"serial=2603160,num_send_frames=1024"'
  states: {}
- name: tx_gain_db
  id: variable
  parameters:
    comment: Absolute B210 TX gain in dB.
    value: '100'
  states: {}
- name: tx_seconds
  id: variable
  parameters:
    comment: TX 持续时间，Head 会自动用 samp_rate * tx_seconds 算出样本数。
    value: '50'
  states: {}
- name: waveform_file
  id: variable
  parameters:
    comment: One 20 ms fc32 chirp period generated by chime_wideband_make_tx_waveform.py.
    value: r"D:\Desktop\fingerprint_localization\dong\inputs\chime_test_tx_period_fc32.bin"
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: int(samp_rate * tx_seconds)
    type: complex
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    comment: Loads one chirp period into host memory at startup, then repeats from memory. This avoids runtime File Source stalls that can cause TX underflows.
    repeat: 'True'
    type: complex
    vector: __import__('numpy').fromfile(waveform_file, dtype=__import__('numpy').complex64)
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: rf_bandwidth
    center_freq0: center_freq
    clock_source0: internal
    dev_addr: tx_device_addr
    dev_args: '""'
    gain0: tx_gain_db
    otw: sc16
    samp_rate: samp_rate
    stream_args: '""'
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [blocks_head_0, '0', uhd_usrp_sink_0, '0']
- [blocks_vector_source_x_0, '0', blocks_head_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
