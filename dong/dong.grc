options:
  parameters:
    author: guang
    generate_options: qt_gui
    id: dong
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: BW
  id: variable
  parameters:
    value: '125000'
  states: {}
- name: CF
  id: variable
  parameters:
    value: '487700000'
  states: {}
- name: EXPID
  id: variable
  parameters:
    value: r"\2_0_53_11_2_16"
  states: {}
- name: IQ_Root
  id: variable
  parameters:
    value: r"D:\Desktop\fingerprint_localization\dong\outputs\captures" + EXPID
  states: {}
- name: NOP
  id: variable
  parameters:
    value: int(samp_rate*1)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '500000'
  states: {}
- name: samp_time
  id: variable
  parameters:
    value: int(samp_rate*1)
  states: {}
- name: blocks_file_sink_0_0_1
  id: blocks_file_sink
  parameters:
    file: IQ_Root + ".bin"
    type: complex
    unbuffered: 'True'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__ will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, example_param=1.0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Embedded Python Block',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.float32]  # 修改为输出实数类型
              )
              self.example_param = example_param

          def work(self, input_items, output_items):
              """Show received signal power in dBFS for quick RF checks."""
              output_items[0][:] = 20.0 * np.log10(np.abs(input_items[0]) + 1e-12)
              return len(output_items[0])
    example_param: '1.0'
  states: {}
- name: qtgui_time_sink_x_1_4_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    entags: 'False'
    grid: 'True'
    name: '"LoRa"'
    size: samp_time
    srate: samp_rate
    type: float
    update_time: '0.1'
    ylabel: Power
    ymax: '10'
    ymin: '-100'
    yunit: '"dBFS"'
  states: {}
- name: uhd_usrp_source_0_0_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    bw0: BW
    center_freq0: CF
    dev_addr: serial=2603160
    gain0: '00.6'
    gain_type0: normalized
    otw: sc8
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [epy_block_0, '0', qtgui_time_sink_x_1_4_0, '0']
- [uhd_usrp_source_0_0_0, '0', blocks_file_sink_0_0_1, '0']
- [uhd_usrp_source_0_0_0, '0', epy_block_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
