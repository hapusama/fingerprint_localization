options:
  parameters:
    author: guang
    category: '[Dong]'
    description: Stable no-GUI USRP B210 IQ capture for high sample rates
    gen_cmake: 'Off'
    generate_options: no_gui
    id: dong_capture_stable
    output_language: python
    title: Dong Stable Capture
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    comment: Use 500000 for LoRa decoding; use 20000000 only for wideband tests.
    value: '20000000'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: '487700000'
  states: {}
- name: rf_bandwidth
  id: variable
  parameters:
    comment: Match this to the analog bandwidth you need.
    value: '10000000'
  states: {}
- name: rx_gain
  id: variable
  parameters:
    comment: Normalized RX gain.
    value: '0.6'
  states: {}
- name: capture_seconds
  id: variable
  parameters:
    comment: Finite capture length. 20 MS/s fc32 is about 160 MB/s.
    value: '5'
  states: {}
- name: capture_samples
  id: variable
  parameters:
    value: int(samp_rate * capture_seconds)
  states: {}
- name: device_addr
  id: variable
  parameters:
    comment: Leave empty to auto-select the only attached USRP, or set "serial=xxxx".
    value: '""'
  states: {}
- name: output_file
  id: variable
  parameters:
    comment: Output is GNU Radio complex64/fc32 IQ.
    value: r"D:\Desktop\fingerprint_localization\dong\outputs\captures\stable_capture_fc32.bin"
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    bw0: rf_bandwidth
    center_freq0: center_freq
    clock_source0: internal
    dev_addr: device_addr
    dev_args: '""'
    gain0: rx_gain
    gain_type0: normalized
    otw: sc16
    rx_agc0: Disabled
    samp_rate: samp_rate
    stream_args: '""'
    sync: pc_clock
    type: fc32
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: capture_samples
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    comment: Buffered file sink. Keep unbuffered off for high-rate capture.
    file: output_file
    type: complex
  states: {}

connections:
- [uhd_usrp_source_0, '0', blocks_head_0, '0']
- [blocks_head_0, '0', blocks_file_sink_0, '0']

metadata:
  file_format: 1
