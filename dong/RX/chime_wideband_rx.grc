options:
  parameters:
    author: oyc
    category: '[Dong]'
    description: Low-rate raw IQ receiver for Chime-style chirp sounding
    gen_cmake: 'Off'
    generate_options: qt_gui
    id: chime_wideband_rx
    output_language: python
    run_options: run
    title: Chime Wideband RX
  states: {}

blocks:
- name: capture_add_timestamp
  id: variable
  parameters:
    comment: Add YYYYMMDD_HHMMSS to avoid overwriting earlier captures.
    value: 'True'
  states: {}
- name: capture_name
  id: variable
  parameters:
    comment: Base filename without extension. Use only filename-safe characters.
    value: '"chime_capture"'
  states: {}
- name: capture_output_dir
  id: variable
  parameters:
    comment: Change this before running. Desktop/data is used for local capture files.
    value: r"/Users/siri/Desktop/data"
  states: {}
- name: capture_output_dir_ready
  id: variable
  parameters:
    comment: Creates the output directory before File Sink opens the file.
    value: __import__("pathlib").Path(capture_output_dir).expanduser().mkdir(parents=True, exist_ok=True)
  states: {}
- name: capture_samples
  id: variable
  parameters:
    value: int(samp_rate * capture_seconds)
  states: {}
- name: capture_seconds
  id: variable
  parameters:
    comment: 20 Msps fc32 is about 160 MB/s; 10 s records about 1.6 GB.
    value: '10'
  states: {}
- name: capture_timestamp
  id: variable
  parameters:
    comment: Evaluated when the flowgraph starts.
    value: __import__("time").strftime("%Y%m%d_%H%M%S")
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: '487700000'
  states: {}
- name: gui_decim
  id: variable
  parameters:
    comment: Decimate only the GUI monitor branch; file capture still records full-rate IQ.
    value: '20'
  states: {}
- name: output_file
  id: variable
  parameters:
    comment: GNU Radio complex64/fc32 IQ output path assembled from capture settings.
    value: str(__import__("pathlib").Path(capture_output_dir).expanduser() / (capture_name + ("_" + capture_timestamp if capture_add_timestamp else "") + ".bin"))
  states: {}
- name: rf_bandwidth
  id: variable
  parameters:
    value: '20000000'
  states: {}
- name: rx_device_addr
  id: variable
  parameters:
    comment: Change this if the RX USRP is the other radio. Extra UHD receive frames help absorb host scheduling jitter at 20 MS/s.
    value: '"serial=2603160,num_recv_frames=512"'
  states: {}
- name: rx_antenna
  id: variable
  parameters:
    comment: B210 RX input. Change to RX2 if the receive antenna is connected there.
    value: '"TX/RX"'
  states: {}
- name: rx_gain_db
  id: variable
  parameters:
    comment: Absolute B210 RX gain in dB.
    value: '40'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '20000000'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters:
    comment: Envelope display for the dedicated time-domain monitor.
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    comment: Buffered file sink. Keep unbuffered off for high-rate capture.
    file: output_file
    type: complex
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: capture_samples
    type: complex
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    comment: Lightweight monitor branch for the Qt GUI sink.
    n: gui_decim
    type: complex
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate / gui_decim
    comment: Real-time decimated monitor; close the Qt window after capture ends.
    fc: center_freq
    fftsize: '2048'
    name: '"RX Monitor"'
    plotconst: 'False'
    plottime: 'False'
    showrf: 'True'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    comment: Magnitude time display. This is easier to see than raw I/Q.
    ctrlpanel: 'True'
    entags: 'False'
    grid: 'True'
    label1: Magnitude
    name: '"RX Magnitude Time"'
    size: int((samp_rate / gui_decim) * 0.02)
    srate: samp_rate / gui_decim
    type: float
    update_time: '0.1'
    ylabel: Magnitude
    ymin: '0'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: rx_antenna
    bw0: rf_bandwidth
    center_freq0: center_freq
    clock_source0: internal
    dev_addr: rx_device_addr
    dev_args: '""'
    gain0: rx_gain_db
    otw: sc16
    rx_agc0: Disabled
    samp_rate: samp_rate
    stream_args: '""'
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_head_0, '0', blocks_file_sink_0, '0']
- [blocks_head_0, '0', blocks_keep_one_in_n_0, '0']
- [blocks_keep_one_in_n_0, '0', blocks_complex_to_mag_0, '0']
- [blocks_keep_one_in_n_0, '0', qtgui_sink_x_0, '0']
- [uhd_usrp_source_0, '0', blocks_head_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
