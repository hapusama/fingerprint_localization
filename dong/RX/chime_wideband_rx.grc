options:
  parameters:
    author: oyc
    category: '[Dong]'
    description: Low-rate raw IQ receiver for Chime-style chirp sounding
    gen_cmake: 'Off'
    generate_options: qt_gui
    id: chime_wideband_rx
    output_language: python
    run_options: run
    title: Chime Wideband RX
  states: {}

blocks:
- name: capture_samples
  id: variable
  parameters:
    value: int(samp_rate * capture_seconds)
  states: {}
- name: capture_seconds
  id: variable
  parameters:
    comment: 2 Msps fc32 is about 16 MB/s. Increase sample rate only after this test is stable.
    value: '10'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: '487700000'
  states: {}
- name: output_file
  id: variable
  parameters:
    comment: GNU Radio complex64/fc32 IQ output.
    value: r"D:\Desktop\fingerprint_localization\dong\outputs\captures\chime_test_rx_fc32.bin"
  states: {}
- name: rf_bandwidth
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: rx_device_addr
  id: variable
  parameters:
    comment: Change this if the RX USRP is the other radio.
    value: '"serial=2603160"'
  states: {}
- name: rx_gain_db
  id: variable
  parameters:
    comment: Absolute B210 RX gain in dB.
    value: '20'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters:
    comment: 把复数 IQ 转成幅度包络 |I+jQ|，方便在时间轴上看脉冲有没有出现。
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    comment: Buffered file sink. Keep unbuffered off for high-rate capture.
    file: output_file
    type: complex
  states: {state: disabled}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: capture_samples
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    comment: 实时观察 RX 幅度包络；默认 25 ms 窗口，可以看到 20 ms 周期 chirp 是否冒出来。
    ctrlpanel: 'True'
    grid: 'True'
    label1: '|IQ| envelope'
    name: RX Time Amplitude
    size: int(samp_rate * 0.025)
    srate: samp_rate
    type: float
    ymin: '0'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    bw0: rf_bandwidth
    center_freq0: center_freq
    clock_source0: internal
    dev_addr: rx_device_addr
    dev_args: '""'
    gain0: rx_gain_db
    otw: sc16
    rx_agc0: Disabled
    samp_rate: samp_rate
    stream_args: '""'
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_0, '0']
- [uhd_usrp_source_0, '0', blocks_complex_to_mag_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
