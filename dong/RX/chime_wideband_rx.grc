options:
  parameters:
    author: guang
    category: '[Dong]'
    description: Low-rate raw IQ receiver for Chime-style chirp sounding
    gen_cmake: 'Off'
    generate_options: no_gui
    id: chime_wideband_rx
    output_language: python
    run_options: run
    title: Chime Wideband RX
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: '487700000'
  states: {}
- name: rf_bandwidth
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: rx_gain_db
  id: variable
  parameters:
    comment: Absolute B210 RX gain in dB.
    value: '20'
  states: {}
- name: rx_device_addr
  id: variable
  parameters:
    comment: Change this if the RX USRP is the other radio.
    value: '"serial=2603160"'
  states: {}
- name: capture_seconds
  id: variable
  parameters:
    comment: 2 Msps fc32 is about 16 MB/s. Increase sample rate only after this test is stable.
    value: '10'
  states: {}
- name: capture_samples
  id: variable
  parameters:
    value: int(samp_rate * capture_seconds)
  states: {}
- name: output_file
  id: variable
  parameters:
    comment: GNU Radio complex64/fc32 IQ output.
    value: r"dong\outputs\captures\chime_test_rx_fc32.bin"
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    bw0: rf_bandwidth
    center_freq0: center_freq
    clock_source0: internal
    dev_addr: rx_device_addr
    dev_args: '""'
    gain0: rx_gain_db
    otw: sc16
    rx_agc0: Disabled
    samp_rate: samp_rate
    stream_args: '""'
    sync: pc_clock
    type: fc32
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: capture_samples
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    comment: Buffered file sink. Keep unbuffered off for high-rate capture.
    file: output_file
    type: complex
  states: {}

connections:
- [uhd_usrp_source_0, '0', blocks_head_0, '0']
- [blocks_head_0, '0', blocks_file_sink_0, '0']

metadata:
  file_format: 1
